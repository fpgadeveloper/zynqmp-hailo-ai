FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI += " \
#    file://allocate-cached-ion-buffer.patch \
#    file://dont-pre-allocate-ion-buffers-gldownload-and-glupload.patch \
#    "

SRC_URI += " \
    "
